# IAR project VMeter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZN64xxx2 Freescale KEAZN64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\APP\RTT; ..\APP; ..\BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\APP\RTT; ..\APP; ..\BSP
  OBJCOPY.OOCOutputFile: AccTester.srec
  ILINK.IlinkOutputFile: VMeter.out
  ILINK.IlinkIcfFile: C:\Embedded\Projects\Light-Control-Module\Firmware_Examples\Voltage_meter\IAR_Proj\KEAZN64xxx2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Voltage_meter/APP
    ../APP/: App_ADC.c App_EEPROM.c Indicator.c main.c Measurements.c
  group Voltage_meter/APP/RTT
    ../APP/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Voltage_meter/BSP
    ../BSP/: ADC.c Cpu.c GPIOA.c PE_LDD.c PIT.c PORT.c SPI0.c SysTick.c Vectors.c
