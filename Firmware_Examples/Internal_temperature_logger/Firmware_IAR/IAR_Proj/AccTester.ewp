# IAR project AccTester.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZN64xxx2 Freescale KEAZN64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\AccTester\Generated_Code; ..\AccTester\Sources\RTT; ..\AccTester\Sources; ..\AccTester\Static_Code\IO_Map; ..\AccTester\Static_Code\PDD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: AccTester.srec
  ILINK.IlinkOutputFile: AccTester.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group AccTester/Generated_Code
    ../AccTester/Generated_Code/: ADC.c Cpu.c GPIOA.c PE_LDD.c PIT.c PORT.c SPI0.c SysTick.c Vectors.c
  group AccTester/Sources
    ../AccTester/Sources/: Events.c Indicator.c main.c
  group AccTester/Sources/RTT
    ../AccTester/Sources/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
