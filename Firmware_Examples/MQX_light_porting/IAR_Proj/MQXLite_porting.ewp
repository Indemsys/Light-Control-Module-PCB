# IAR project MQXLite_porting.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZN64xxx2 Freescale KEAZN64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\MQXLite_porting\Generated_Code; ..\MQXLite_porting\MQXLITE\config; ..\MQXLite_porting\MQXLITE\include; ..\MQXLite_porting\MQXLITE\psp\cortex_m\compiler\iar; ..\MQXLite_porting\MQXLITE\psp\cortex_m\core\M0; ..\MQXLite_porting\MQXLITE\psp\cortex_m; ..\MQXLite_porting\Sources\RTT; ..\MQXLite_porting\Sources; ..\MQXLite_porting\Static_Code\IO_Map; ..\MQXLite_porting\Static_Code\PDD
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: AccTester.srec
  ILINK.IlinkOutputFile: MQXLite_porting.out
  ILINK.IlinkIcfFile: C:\Embedded\Projects\Light-Control-Module\Firmware_Examples\MQX_light_porting\MQXLite_porting\Project_Settings\Linker_Files\ProcessorExpert.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group MQXLite_porting/Generated_Code
    ../MQXLite_porting/Generated_Code/: ADC.c Cpu.c GPIOA.c MQX1.c PE_LDD.c PIT.c PORT.c SPI0.c SystemTimer1.c Vectors.c
  group MQXLite_porting/MQXLITE/config
    ../MQXLite_porting/MQXLITE/config/: task_template_list.c
  group MQXLite_porting/MQXLITE/kernel
    ../MQXLite_porting/MQXLITE/kernel/: idletask.c int.c klog.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mqx_utils.c mqxlite.c mutex.c qu_test.c sched.c task.c time_ticks.c
  group MQXLite_porting/MQXLITE/psp/cortex_m
    ../MQXLite_porting/MQXLITE/psp/cortex_m/: cortex.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c mem_zero.c psp_iinit.c psp_supp.c psp_tiad.c psp_tinm.c psp_tipr.c psp_tisu.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c
  group MQXLite_porting/MQXLITE/psp/cortex_m/core/M0
    ../MQXLite_porting/MQXLITE/psp/cortex_m/core/M0/: boot.S dispatch.S
  group MQXLite_porting/Sources
    ../MQXLite_porting/Sources/: App_ADC.c App_io.c App_UART.c Indicator.c Measurements.c mqx_tasks.c PWM_gen.c
  group MQXLite_porting/Sources/RTT
    ../MQXLite_porting/Sources/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
